FILES_${PN} += "/usr/lib/perl5"
FILES_${PN}-dbg += "/usr/lib/perl5/auto/OpenIPMI/.debug"
