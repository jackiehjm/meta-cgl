do_install_append(){
        chmod o+x ${D}${base_sbindir}/shutdown
}
