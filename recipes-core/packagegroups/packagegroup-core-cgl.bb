SUMMARY = "Carrier Grade Linux (CGL)"
DESCRIPTION = "Packages required to satisfy the Carrier Grade Linux (CGL) specification"


inherit packagegroup


PACKAGES = ""

RDEPENDS_packagegroup-custom-apps = ""

RDEPENDS_packagegroup-custom-tools = ""

RRECOMMENDS_packagegroup-custom-tools = ""
