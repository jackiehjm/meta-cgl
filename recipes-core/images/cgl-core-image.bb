inherit core-image

# Include modules in rootfs
IMAGE_INSTALL += ""

IMAGE_FEATURES += ""
