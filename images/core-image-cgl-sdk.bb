require recipes-extended/images/core-image-lsb-sdk.bb


IMAGE_FEATURES += "dbg-pkgs"
